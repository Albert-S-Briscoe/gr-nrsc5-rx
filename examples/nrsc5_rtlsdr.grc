options:
  parameters:
    author: Albert Briscoe
    generate_options: qt_gui
    id: nrsc5_rtlsdr
    output_language: python
    title: RTL-SDR NRSC-5 Receiver
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: Frequency
    start: 881e5
    step: 2e5
    stop: 1079e5
    value: 915e5
  states: {}
- name: program
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,0
    label: Program
    label0: HD-1
    label1: HD-2
    label2: HD-3
    label3: HD-4
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1200000'
  states: {}
- name: sdr_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0
    label: SDR Gain
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: audio_rate
  states: {}
- name: nrsc5_rx_nrsc_5_receiver_0
  id: nrsc5_rx_nrsc_5_receiver
  parameters:
    audio_rate: audio_rate
    program: program
    samp_rate: samp_rate
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,10,1
    plotconst: 'False'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    freq0: freq
    gain0: sdr_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [nrsc5_rx_nrsc_5_receiver_0, '0', audio_sink_0, '0']
- [nrsc5_rx_nrsc_5_receiver_0, '1', audio_sink_0, '1']
- [rtlsdr_source_0, '0', nrsc5_rx_nrsc_5_receiver_0, '0']
- [rtlsdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
