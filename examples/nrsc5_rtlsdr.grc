options:
  parameters:
    author: Albert Briscoe
    generate_options: qt_gui
    id: nrsc5_rtlsdr
    output_language: python
    title: RTL-SDR NRSC-5 Receiver
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    comment: Must be 44.1khz
    value: '44100'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: Frequency
    start: 881e5
    step: 2e5
    stop: 1079e5
    value: 915e5
  states: {}
- name: program
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,0
    label: Program
    label0: HD-1
    label1: HD-2
    label2: HD-3
    label3: HD-4
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Must be 744187.5
    value: '744187.5'
  states: {}
- name: sdr_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0
    label: SDR Gain
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: sdr_rate
  id: variable
  parameters:
    value: '1200000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: audio_rate
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '32767'
    vector_output: 'True'
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: blocks_short_to_float_1
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: audio_rate
    type: float
  states: {}
- name: blocks_throttle_1_0
  id: blocks_throttle
  parameters:
    samples_per_second: audio_rate
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '320000'
    decim: '1'
    gain: '1'
    samp_rate: sdr_rate
    type: fir_filter_ccf
    width: '50000'
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: sdr_rate/samp_rate
    type: complex
  states: {}
- name: nrsc5_rx_nrsc5_rx_1
  id: nrsc5_rx_nrsc5_rx
  parameters:
    program: program
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,10,1
    plotconst: 'False'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    freq0: freq
    gain0: sdr_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: sdr_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_interleaved_short_0, '0', nrsc5_rx_nrsc5_rx_1, '0']
- [blocks_short_to_float_0, '0', blocks_throttle_1, '0']
- [blocks_short_to_float_1, '0', blocks_throttle_1_0, '0']
- [blocks_throttle_1, '0', audio_sink_0, '0']
- [blocks_throttle_1_0, '0', audio_sink_0, '1']
- [low_pass_filter_0, '0', mmse_resampler_xx_0, '0']
- [mmse_resampler_xx_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [mmse_resampler_xx_0, '0', qtgui_sink_x_0, '0']
- [nrsc5_rx_nrsc5_rx_1, '0', blocks_short_to_float_0, '0']
- [nrsc5_rx_nrsc5_rx_1, '1', blocks_short_to_float_1, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
