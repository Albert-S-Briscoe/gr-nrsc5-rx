options:
  parameters:
    author: Albert Briscoe
    generate_options: qt_gui
    id: nrsc5_rtlsdr
    output_language: python
    title: Demo NRSC-5 flowgraph using rtl_sdr
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: Frequency
    start: 881e5
    step: 2e5
    stop: 1079e5
    value: 915e5
  states: {}
- name: program
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,0
    label: Program
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '44100'
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '32767'
    vector_output: 'True'
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: blocks_short_to_float_1
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: '44100'
    type: float
  states: {}
- name: blocks_throttle_1_0
  id: blocks_throttle
  parameters:
    samples_per_second: '44100'
    type: float
  states: {}
- name: nrsc5_rx_nrsc5_rx_1
  id: nrsc5_rx_nrsc5_rx
  parameters:
    program: program
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '744187.5'
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0,10,1
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '12800'
    interp: '3969'
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    freq0: freq
    gain0: '45'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_interleaved_short_0, '0', nrsc5_rx_nrsc5_rx_1, '0']
- [blocks_short_to_float_0, '0', blocks_throttle_1, '0']
- [blocks_short_to_float_1, '0', blocks_throttle_1_0, '0']
- [blocks_throttle_1, '0', audio_sink_0, '0']
- [blocks_throttle_1_0, '0', audio_sink_0, '1']
- [nrsc5_rx_nrsc5_rx_1, '0', blocks_short_to_float_0, '0']
- [nrsc5_rx_nrsc5_rx_1, '1', blocks_short_to_float_1, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
