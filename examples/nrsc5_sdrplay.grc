options:
  parameters:
    author: Albert Briscoe
    generate_options: qt_gui
    id: nrsc5_sdrplay
    output_language: python
    title: SDRPlay NRSC-5 Receiver
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: Frequency
    start: 881e5
    step: 2e5
    stop: 1079e5
    value: 915e5
  states: {}
- name: program
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,0
    label: Program
    label0: HD-1
    label1: HD-2
    label2: HD-3
    label3: HD-4
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: rsp_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0
    label: SDR Gain
    start: '-47'
    step: '1'
    stop: '0'
    value: '-45'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3000000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: audio_rate
  states: {}
- name: nrsc5_rx_nrsc_5_receiver_0
  id: nrsc5_rx_nrsc_5_receiver
  parameters:
    audio_rate: audio_rate
    program: program
    samp_rate: samp_rate
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,10,1
    plotconst: 'False'
    type: complex
  states: {}
- name: soapy_sdrplay_source_0
  id: soapy_sdrplay_source
  parameters:
    bandwidth: '5000000.0'
    center_freq: freq
    gain: rsp_gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [nrsc5_rx_nrsc_5_receiver_0, '0', audio_sink_0, '0']
- [nrsc5_rx_nrsc_5_receiver_0, '1', audio_sink_0, '1']
- [soapy_sdrplay_source_0, '0', nrsc5_rx_nrsc_5_receiver_0, '0']
- [soapy_sdrplay_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
